#include "ring/json_stream.h"

#include <cmath>
#include <cstdlib>
#include <cstring>

namespace swan {
namespace json {

namespace {
bool is_ws(char c) { return c == ' ' || c == '\t' || c == '\n' || c == '\r'; }
bool is_num_char(char c) {
    return (c >= '0' && c <= '9') || c == '-' || c == '+' || c == '.' || c == 'e' || c == 'E';
}
void append_utf8(std::string& out, uint32_t cp) {
    if (cp < 0x80) {
        out.push_back(static_cast<char>(cp));
    } else if (cp < 0x800) {
        out.push_back(static_cast<char>(0xC0 | (cp >> 6)));
        out.push_back(static_cast<char>(0x80 | (cp & 0x3F)));
    } else if (cp < 0x10000) {
        out.push_back(static_cast<char>(0xE0 | (cp >> 12)));
        out.push_back(static_cast<char>(0x80 | ((cp >> 6) & 0x3F)));
        out.push_back(static_cast<char>(0x80 | (cp & 0x3F)));
    } else {
        out.push_back(static_cast<char>(0xF0 | (cp >> 18)));
        out.push_back(static_cast<char>(0x80 | ((cp >> 12) & 0x3F)));
        out.push_back(static_cast<char>(0x80 | ((cp >> 6) & 0x3F)));
        out.push_back(static_cast<char>(0x80 | (cp & 0x3F)));
    }
}
bool is_high_surrogate(uint32_t cp) { return cp >= 0xD800 && cp <= 0xDBFF; }
bool is_low_surrogate(uint32_t cp) { return cp >= 0xDC00 && cp <= 0xDFFF; }
}  // namespace

bool StreamParser::fail(const char* why) {
    if (err_.empty()) err_ = why;
    return false;
}

bool StreamParser::push_ctx(Ctx c) {
    if (depth_ >= STREAM_DEPTH_MAX) return fail("nested too deeply");
    stack_[depth_++] = c;
    return true;
}

bool StreamParser::pop_ctx(Ctx expect) {
    if (depth_ == 0 || stack_[depth_ - 1] != expect) return fail("mismatched bracket");
    --depth_;
    return true;
}

bool StreamParser::emit_scalar() {
    // A completed string or number, delivered to the handler.  tok_ is reused
    // rather than reallocated, which is the point of the whole exercise.
    if (tok_is_key_) {
        if (!h_.on_key(tok_)) return fail(h_.err.empty() ? "rejected key" : h_.err.c_str());
    } else if (!h_.on_string(tok_)) {
        return fail(h_.err.empty() ? "rejected value" : h_.err.c_str());
    }
    tok_.clear();
    return true;
}

bool StreamParser::step(char c) {
    switch (st_) {
        case St::Value:
            if (is_ws(c)) return true;
            if (c == '{') {
                if (!push_ctx(Ctx::Object)) return false;
                if (!h_.on_object_begin()) return fail(h_.err.empty() ? "rejected object"
                                                                     : h_.err.c_str());
                st_ = St::Key;
                return true;
            }
            if (c == '[') {
                if (!push_ctx(Ctx::Array)) return false;
                if (!h_.on_array_begin()) return fail(h_.err.empty() ? "rejected array"
                                                                    : h_.err.c_str());
                st_ = St::Value;
                return true;
            }
            if (c == ']') {   // an empty array
                if (!pop_ctx(Ctx::Array)) return false;
                if (!h_.on_array_end()) return fail(h_.err.empty() ? "rejected array end"
                                                                  : h_.err.c_str());
                st_ = St::AfterValue;
                if (depth_ == 0) done_ = true;
                return true;
            }
            if (c == '"') {
                tok_.clear();
                tok_is_key_ = false;
                st_ = St::InString;
                return true;
            }
            if (is_num_char(c)) {
                tok_.clear();
                tok_.push_back(c);
                st_ = St::InNumber;
                return true;
            }
            if (c == 't' || c == 'f' || c == 'n') {
                lit_.clear();
                lit_.push_back(c);
                st_ = St::InLiteral;
                return true;
            }
            return fail("unexpected character where a value was expected");

        case St::InString:
            // A high surrogate is only half a character: the very next thing
            // must be its escaped partner, or the string carries a codepoint
            // that does not exist.
            if (high_surrogate_ != 0 && c != '\\') return fail("unpaired surrogate escape");
            if (c == '\\') {
                st_ = St::InEscape;
                return true;
            }
            if (c == '"') {
                st_ = tok_is_key_ ? St::AfterKey : St::AfterValue;
                if (!emit_scalar()) return false;
                if (st_ == St::AfterValue && depth_ == 0) done_ = true;
                return true;
            }
            if (static_cast<unsigned char>(c) < 0x20) return fail("control character in a string");
            if (tok_.size() >= STREAM_TOKEN_MAX) return fail("string too long");
            tok_.push_back(c);
            return true;

        case St::InEscape:
            if (high_surrogate_ != 0 && c != 'u') return fail("unpaired surrogate escape");
            st_ = St::InString;
            switch (c) {
                case '"':  tok_.push_back('"');  return true;
                case '\\': tok_.push_back('\\'); return true;
                case '/':  tok_.push_back('/');  return true;
                case 'b':  tok_.push_back('\b'); return true;
                case 'f':  tok_.push_back('\f'); return true;
                case 'n':  tok_.push_back('\n'); return true;
                case 'r':  tok_.push_back('\r'); return true;
                case 't':  tok_.push_back('\t'); return true;
                case 'u':
                    uni_ = 0;
                    uni_val_ = 0;
                    st_ = St::InUnicode;
                    return true;
                default: return fail("bad escape");
            }

        case St::InUnicode: {
            uint32_t d = 0;
            if (c >= '0' && c <= '9') d = static_cast<uint32_t>(c - '0');
            else if (c >= 'a' && c <= 'f') d = static_cast<uint32_t>(c - 'a' + 10);
            else if (c >= 'A' && c <= 'F') d = static_cast<uint32_t>(c - 'A' + 10);
            else return fail("bad \\u escape");
            uni_val_ = (uni_val_ << 4) | d;
            if (++uni_ == 4) {
                //   is refused for the same reason json_lite refuses it:
                // it would smuggle a NUL into a C string downstream.
                if (uni_val_ == 0) return fail("\\u0000 is not allowed");
                uint32_t cp = uni_val_;
                if (high_surrogate_ != 0) {
                    if (!is_low_surrogate(cp)) return fail("unpaired surrogate escape");
                    cp = 0x10000 + ((high_surrogate_ - 0xD800) << 10) + (cp - 0xDC00);
                    high_surrogate_ = 0;
                } else if (is_high_surrogate(cp)) {
                    // Hold it: the next two characters must be a backslash-u
                    // and the low half.  Nothing is emitted until the pair is
                    // complete, so a string can never end with half a
                    // codepoint in it.
                    high_surrogate_ = cp;
                    st_ = St::InString;
                    return true;
                } else if (is_low_surrogate(cp)) {
                    return fail("unpaired surrogate escape");
                }
                if (tok_.size() + 4 > STREAM_TOKEN_MAX) return fail("string too long");
                append_utf8(tok_, cp);
                st_ = St::InString;
            }
            return true;
        }

        case St::InNumber:
            if (is_num_char(c)) {
                if (tok_.size() >= 40) return fail("number too long");
                tok_.push_back(c);
                return true;
            }
            if (!h_.on_number(std::strtod(tok_.c_str(), nullptr))) {
                return fail(h_.err.empty() ? "rejected number" : h_.err.c_str());
            }
            tok_.clear();
            st_ = St::AfterValue;
            if (depth_ == 0) done_ = true;
            return step(c);   // re-handle the delimiter that ended the number

        case St::InLiteral:
            if (c >= 'a' && c <= 'z') {
                if (lit_.size() >= 5) return fail("bad literal");
                lit_.push_back(c);
                return true;
            }
            // fall through to completion below
            [[fallthrough]];

        case St::AfterValue:
            if (st_ == St::InLiteral) {
                bool ok = false;
                if (lit_ == "true") ok = h_.on_bool(true);
                else if (lit_ == "false") ok = h_.on_bool(false);
                else if (lit_ == "null") ok = h_.on_null();
                else return fail("bad literal");
                if (!ok) return fail(h_.err.empty() ? "rejected literal" : h_.err.c_str());
                lit_.clear();
                st_ = St::AfterValue;
                if (depth_ == 0) done_ = true;
                return step(c);
            }
            if (is_ws(c)) return true;
            if (c == ',') {
                if (depth_ == 0) return fail("comma outside a container");
                st_ = stack_[depth_ - 1] == Ctx::Object ? St::Key : St::Value;
                return true;
            }
            if (c == '}') {
                if (!pop_ctx(Ctx::Object)) return false;
                if (!h_.on_object_end()) return fail(h_.err.empty() ? "rejected object end"
                                                                    : h_.err.c_str());
                if (depth_ == 0) done_ = true;
                return true;
            }
            if (c == ']') {
                if (!pop_ctx(Ctx::Array)) return false;
                if (!h_.on_array_end()) return fail(h_.err.empty() ? "rejected array end"
                                                                   : h_.err.c_str());
                if (depth_ == 0) done_ = true;
                return true;
            }
            return fail("expected a comma or a closing bracket");

        case St::Key:
            if (is_ws(c)) return true;
            if (c == '}') {   // an empty object
                if (!pop_ctx(Ctx::Object)) return false;
                if (!h_.on_object_end()) return fail(h_.err.empty() ? "rejected object end"
                                                                    : h_.err.c_str());
                st_ = St::AfterValue;
                if (depth_ == 0) done_ = true;
                return true;
            }
            if (c == '"') {
                tok_.clear();
                tok_is_key_ = true;
                st_ = St::InString;
                return true;
            }
            return fail("expected a key");

        case St::AfterKey:
            if (is_ws(c)) return true;
            if (c == ':') {
                tok_is_key_ = false;
                st_ = St::Value;
                return true;
            }
            return fail("expected a colon");
    }
    return fail("bad state");
}

bool StreamParser::feed(std::string_view chunk) {
    if (!err_.empty()) return false;
    for (const char c : chunk) {
        // Trailing whitespace after the root value is fine; anything else is a
        // second document, which is a truncation or a smuggling attempt.
        if (done_ && !is_ws(c)) return fail("trailing data after the document");
        if (done_) continue;
        if (!step(c)) return false;
        if (done_) seen_root_ = true;
    }
    return true;
}

bool StreamParser::finish() {
    if (!err_.empty()) return false;
    // A number at the very end has no delimiter to close it.
    if (st_ == St::InNumber) {
        if (!h_.on_number(std::strtod(tok_.c_str(), nullptr))) return fail("rejected number");
        tok_.clear();
        st_ = St::AfterValue;
        done_ = true;
    } else if (st_ == St::InLiteral) {
        bool ok = false;
        if (lit_ == "true") ok = h_.on_bool(true);
        else if (lit_ == "false") ok = h_.on_bool(false);
        else if (lit_ == "null") ok = h_.on_null();
        else return fail("bad literal");
        if (!ok) return fail("rejected literal");
        done_ = true;
    }
    if (depth_ != 0) return fail("truncated document");
    if (!done_ && !seen_root_) return fail("empty document");
    return true;
}

}  // namespace json
}  // namespace swan
